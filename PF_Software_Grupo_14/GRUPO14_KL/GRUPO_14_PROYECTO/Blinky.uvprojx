# Keil uVision project Blinky.uvprojx, settings and files
target Blinky (6190000::V6.19::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=5
  c include: ./Drivers;./Startup;.\Dispositivos;.\Aplicacion
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Startup
    ./Startup/: MKL25Z4.h startup_MKL25Z4.s system_MKL25Z4.c system_MKL25Z4.h
  group Source
    ./: main.c
  group Drivers
    ./Drivers/: GPIO.c GPIO.h TPM.c TPM.h UART.c UART.h SPI.c SPI.h Fonts.h ILI9341.h SysTick.c SysTick.h
  group Dispositivo
    ./Dispositivos/: Comandos.c Comandos.h Inicializacion.c Inicializacion.h TFT.c TFT.h CNY70.c CNY70.h NEMA17.c NEMA17.h Teclado.c Teclado.h Antirrebote.c Antirrebote.h TRIAC.c TRIAC.h
  group Aplicacion
    ./Aplicacion/: protocolo.c protocolo.h Bordado.c Bordado.h
software components: CMSIS:CORE 5.6.0
